## main/Kconfig.projbuild
```kconfig
menu "iButtonConfiguration"

	config BUTTON_IO_PIN
		int "iButton IO pin"
		default 10

endmenu
```
